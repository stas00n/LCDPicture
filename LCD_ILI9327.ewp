# IAR project LCD_ILI9327.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030
  ICCARM.CCIncludePath2: CMSIS/; SPL/; ; fatfs/; utils/
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: STM32F030R8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: hardware.h lcd.cpp lcd.h main.cpp main.h myf.cpp periph.c periph.h stm32f0xx_conf.h timecrit.s
    ../../C/: main.ENU.projtempl
    Pictures/: x4548y2605.c x4548y2606.c
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cmFunc.h core_cmInstr.h startup_stm32f030.s stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group fatfs
    fatfs/: diskio.c ff.c ff.h ffconf.h integer.h
  group SPL
    SPL/: stm32f0xx_crc.c stm32f0xx_crc.h stm32f0xx_dbgmcu.c stm32f0xx_dbgmcu.h stm32f0xx_dma.c stm32f0xx_dma.h stm32f0xx_gpio.c stm32f0xx_gpio.h stm32f0xx_misc.c stm32f0xx_misc.h stm32f0xx_rcc.c stm32f0xx_rcc.h stm32f0xx_spi.c stm32f0xx_spi.h stm32f0xx_syscfg.c stm32f0xx_syscfg.h stm32f0xx_tim.c stm32f0xx_tim.h stm32f0xx_usart.c stm32f0xx_usart.h
  group utils
    utils/: gpioex.c gpioex.h Timing.c Timing.h utils.c utils.h
